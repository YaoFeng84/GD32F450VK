# Keil uVision project GD32F450VKT6.uvprojx, settings and files
target GD32F450VK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F450VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F450VKT6 (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F450,USE_USB_FS
  c include: ..\GD32F450VK_Code\CommHead;..\GD32F450VK_Code\CommHead\CMSIS;..\GD32F450VK_Code\CommHead\Peripherals;..\GD32F450VK_Code\CommHead\USB;..\..\..\MyCodeLib
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group sys
    ../GD32F450VK_Code/CommSrc/: system_gd32f4xx.c
  group lib
    ../GD32F450VK_Code/CommSrc/Peripherals/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group usblib
    ../GD32F450VK_Code/CommSrc/USB/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c usbd_core.c usbd_enum.c usbd_transc.c
  group DRI
    ../GD32F450VK_Code/: DRI_ComDriver.c DRI_CLK.c DRI_GPIO.c DRI_USARTn.c DRI_Systick.c DRI_Flash.c DRI_ExINT.c DRI_USB.c DRI_RCU.c DRI_CAN.c
